options:
  parameters:
    generate_options: qt_gui
    id: rtl_sdr_gps_sampler
    output_language: python
    title: RTL-SDR GPS sampler
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 1.023e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1571.42e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 1575.42e6
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16*1.023e6
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: str(datetime.now(timezone.utc).timestamp())
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''./samples-g11_24_62-front-hackrf-DDC'' + timestamp'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime, timezone
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import re
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '1'
    bb_gain0: '62'
    freq0: center_freq
    gain0: '11'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/8
    fc: channel_freq
    fftsize: '8192'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
